options:
  parameters:
    generate_options: qt_gui
    id: FMtran
    output_language: python
    title: FMtran
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.2'
  states: {}
- name: audioRate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: center_fr
  id: variable_qtgui_range
  parameters:
    start: 50e6
    step: '1'
    stop: 200e6
    value: 80e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audioRate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: audioRate*4
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Windows\Media\Alarm01.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    clock_source0: internal
    freq0: center_fr
    gain0: '20'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '176400'
    interp: samp_rate
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
